# Repository ghlee0786/OpenHW (continued)

## KiCad design hardware/schematic/carrier/carrier.kicad_pcb

Parts:
C1: 47uF/35V; CP_Elec_6.3x5.4
C2, C3, C4, C11: 10uF/25V; C_1206_3216Metric
C5: 100nF/50V; C_0402_1005Metric
C6, C14, C21: 100nF; C_0402_1005Metric
C7, C8, C20: 22uF/25V X7R; C_1210_3225Metric
C9: 22nF; C_0402_1005Metric
C10: 1uF/25V; C_0603_1608Metric
C12: 1uF; C_0402_1005Metric
C13: 1uF; C_0603_1608Metric
C15, C16: 100nF; C_0402_1005Metric; not fitted
C17: 1nF/2kV; C_1206_3216Metric
C18, C22: 10nF; C_0402_1005Metric
C19: 75pF C0G 50V; C_0402_1005Metric
C23: 22uF/25V X7R; C_1210_3225Metric; MPN Samsung CL32B226KAJNNNE
D1: BZT52C12; D_SOD-123
D2: SMBJ15A; D_SMB; MPN Littelfuse SMBJ15A (LCSC C83846)
D3: PWR green; LED_0603_1608Metric
D4, D5: UDD32C03L01; D_SOD-323
D6: STATUS blue; LED_0603_1608Metric
D7: SMBJ6.0A; D_SMB; MPN SMBJ6.0A (VRWM 6.0V > Vout max 5.30V, V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
F1: 3A slow-blow 63V; Fuse_1206_3216Metric; MPN Bel Fuse 0685T3000-01 (1206 Slow Blow 3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
J1: HC-PBB05-2-60-M-H4.0 (ST-BTB-058060-A); BTB_ST-BTB-058060-A_2x30_P0.5mm; MPN HCTL HC-PBB05-2-60-M-H4.0-G1-R-P-04 / a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
J2: DC-005-5A-2.0; BarrelJack_XKB_DC-005-5A-2.0_Horizontal; MPN XKB DC-005-5A-2.0 (LCSC C381116)
J3: USB-C 16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J4: DM3AT-SF-PEJM5; microSD_HC_Hirose_DM3AT-SF-PEJM5
J5: HR911105A; RJ45_Hanrun_HR911105A_Horizontal; MPN HanRun HR911105A (LCSC C12074)
J6: DEBUG UART; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal
J7: JST GH 6P (board link); JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal; MPN JST SM06B-GHS-TB
L1: 10uH Isat>=6A; L_Bourns_SRP7028A_7.3x6.6mm
Q1: AO4407A; SOIC-8_3.9x4.9mm_P1.27mm; MPN AOS AO4407A (LCSC C16072)
Q2: AO3401A; SOT-23
Q3, Q4: DMG1012T; SOT-523
R1, R10, R11, R12, R20, R23: 100k; R_0402_1005Metric
R2: 78.7k 1%; R_0402_1005Metric
R3: 10.7k 1%; R_0402_1005Metric
R4: 2.2k; R_0402_1005Metric
R5: 10k; R_0402_1005Metric
R6: 6.04k 1%; R_0402_1005Metric
R7, R8: 5.1k; R_0402_1005Metric
R9: 200k; R_0402_1005Metric
R13, R14, R15, R16, R17: 47k; R_0402_1005Metric; not fitted
R18: 1M; R_0603_1608Metric
R19: 1k; R_0402_1005Metric
R21: 1.5k; R_0402_1005Metric
R22: 47k; R_0402_1005Metric
SW1: RESET; SW_SPST_PTS810
SW2: UPGRADE; SW_SPST_PTS810
TP1: 12V_IN; TestPoint_Pad_D1.0mm
TP2: 5V_SYS; TestPoint_Pad_D1.0mm
TP3: 12V_IR; TestPoint_Pad_D1.0mm
TP4: CORE_3V3; TestPoint_Pad_D1.0mm
TP5: SD_PWR_3V3; TestPoint_Pad_D1.0mm
TP6, TP7: GND; TestPoint_Pad_D1.0mm
TP8: USB_DP; TestPoint_Pad_D1.0mm
TP9: USB_DN; TestPoint_Pad_D1.0mm
TP10: USB_DET; TestPoint_Pad_D1.0mm
TP11: nRESET; TestPoint_Pad_D1.0mm
TP12: UPGRAD_KEY; TestPoint_Pad_D1.0mm
TP13: STATUS_LED; TestPoint_Pad_D1.0mm
TP14: IR_LED_EN; TestPoint_Pad_D1.0mm
TP15: SPARE1; TestPoint_Pad_D1.0mm
TP16: I2C1_SDA; TestPoint_Pad_D1.0mm
TP17: I2C1_SCL; TestPoint_Pad_D1.0mm
TP18: RESERVE1; TestPoint_Pad_D1.0mm
TP19: RESERVE2; TestPoint_Pad_D1.0mm
TP20: UART1_RX; TestPoint_Pad_D1.0mm
TP21: UART1_TX; TestPoint_Pad_D1.0mm
TP22: UART1_CTS; TestPoint_Pad_D1.0mm
TP23: UART1_RTS; TestPoint_Pad_D1.0mm
TP24: DEBUG_UART0_TX; TestPoint_Pad_D1.0mm
TP25: DEBUG_UART0_RX; TestPoint_Pad_D1.0mm
TP26: ALS_INT_RSV; TestPoint_Pad_D1.0mm
U1: TPS54302DDCR; SOT-23-6; MPN TI TPS54302DDCR (LCSC C311983)
U2: TPS26600PWPR; HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.66x2.46mm; MPN TI TPS26600PWPR (LCSC C544399)
U3: USBLC6-2SC6; SOT-23-6
U4, U5: TPD4E05U06DQA; USON-10_2.5x1.0mm_P0.5mm

Connections:
/5V_SYS: C7.1, C8.1, C19.1, C20.1, C23.1, D7.1 (K), J1.29, J1.31, J1.33, J1.35, L1.2, R2.1, R4.1, R21.1, TP2.1
/12V_IN: C1.1, C2.1, C3.1, C4.1, C5.1, C10.1, D1.1 (K), D2.1 (K), Q1.1 (S), Q1.2 (S), Q1.3 (S), TP1.1, U1.3 (VIN), U2.1 (IN), U2.2 (IN), U2.3 (UVLO)
/12V_IN_F: F1.2, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D)
/12V_IN_RAW: F1.1, J2.1
/12V_IR: C11.1, J7.2, J7.5, TP3.1, U2.15 (OUT), U2.16 (OUT)
/ALS_INT_RSV: J7.4, TP26.1
/BUCK_BOOT: C6.1, U1.6 (BOOT)
/BUCK_FB: C19.2, R2.2, R3.1, U1.4 (FB)
/BUCK_SW: C6.2, L1.1, U1.2 (SW)
/CHASSIS: C17.1, J5.SH, R18.1
/CORE_3V3: C21.2, J1.27, Q2.2 (S), R11.1, TP4.1
/DEBUG_UART0_RX: J1.60, J6.3, TP25.1
/DEBUG_UART0_TX: J1.58, J6.2, TP24.1
/EFUSE_DVDT: C9.1, U2.12 (dVdT)
/EFUSE_ILIM: R6.1, U2.11 (ILIM)
/EPHY_RXN: D5.2 (A2), J1.10, J5.6 (RD-)
/EPHY_RXP: D5.1 (A1), J1.8, J5.3 (RD+)
/EPHY_TXN: D4.2 (A2), J1.4, J5.2 (TD-)
/EPHY_TXP: D4.1 (A1), J1.2, J5.1 (TD+)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C22.2, C23.2, D2.2 (A), D3.1 (K), D7.2 (A), J1.5, J1.6, J1.12, J1.13, J1.25, J1.28, J1.30, J1.50, J1.54, J2.2, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.SH (SHIELD), J4.6 (VSS), J4.10 (DET_A), J4.SH (SHIELD), J5.8, J6.1, J6.MP (MountPin), J7.1, J7.6, J7.MP (MountPin), Q3.2 (S), Q4.2 (S), R1.2, R3.2, R5.2, R6.2, R7.2, R8.2, R10.2, R12.2, R18.2, R20.2, R23.2, SW1.2, SW2.2, TP6.1, TP7.1, U1.1 (GND), U2.5 (OVP), U2.8 (RTN), U2.9 (GND), U2.17 (RTN), U3.2 (GND), U4.3 (GND), U4.8 (GND), U5.3 (GND), U5.8 (GND)
/I2C1_SCL: J1.18, TP17.1
/I2C1_SDA: J1.16, TP16.1
/IR_LED_EN: J1.22, R5.1, TP14.1, U2.7 (~SHDN)
/MDI_RCT: C16.1, J5.5 (RCT)
/MDI_TCT: C15.1, J5.4 (TCT)
/PWR_LED_A: D3.2 (A), R4.2
/Q1_G: D1.2 (A), Q1.4 (G), R1.1
/RESERVE1: J1.7, TP18.1
/RESERVE2: J1.9, TP19.1
/SD0_PWR_EN: J1.38, Q3.1 (G), R12.1
/SDIO_CD: J1.56, J4.9 (DET_B), U5.4 (D2+)
/SDIO_CLK: J1.52, J4.5 (CLK), U4.1 (D1+)
/SDIO_CMD: J1.48, J4.3 (CMD), R13.2, U4.2 (D1-)
/SDIO_D0: J1.46, J4.7 (DAT0), R14.2, U4.4 (D2+)
/SDIO_D1: J1.44, J4.8 (DAT1), R15.2, U4.5 (D2-)
/SDIO_D2: J1.42, J4.1 (DAT2), R16.2, U5.1 (D1+)
/SDIO_D3: J1.40, J4.2 (DAT3/CD), R17.2, U5.2 (D1-)
/SD_PWR_3V3: C13.1, C14.1, J4.4 (VDD), Q2.3 (D), R13.1, R14.1, R15.1, R16.1, R17.1, R23.1, TP5.1
/SD_PWR_G: C21.1, Q2.1 (G), R22.2
/SD_PWR_GD: Q3.3 (D), R11.2, R22.1
/SPARE1: J1.20, J7.3, TP15.1
/STATUS_LED: J1.24, Q4.1 (G), R20.1, TP13.1
/STAT_LED_A: D6.2 (A), R21.2
/STAT_LED_K: D6.1 (K), Q4.3 (D)
/UART1_CTS: J1.57, TP22.1
/UART1_RTS: J1.59, TP23.1
/UART1_RX: J1.53, TP20.1
/UART1_TX: J1.55, TP21.1
/UPGRAD_KEY: C18.1, J1.36, R19.1, TP12.1
/UPGRAD_KEY_SW: R19.2, SW2.1
/USB_CC1: J3.A5 (CC1), R7.1
/USB_CC2: J3.B5 (CC2), R8.1
/USB_DET: C22.1, J1.14, R9.2, R10.1, TP10.1
/USB_DN: J1.1, J3.A7 (D-), J3.B7 (D-), TP9.1, U3.3 (I/O2), U3.4 (I/O2)
/USB_DP: J1.3, J3.A6 (D+), J3.B6 (D+), TP8.1, U3.1 (I/O1), U3.6 (I/O1)
/USB_VBUS: C12.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R9.1, U3.5 (VBUS)
/nRESET: J1.34, SW1.1, TP11.1

Notes on the sheet:
코어 BTB (J2 짝, ST-BTB-058060-A / HCTL)
계약 4절 핀맵 · 짝 핀 홀짝 반전 · VIN 4핀 = 5V_SYS 피크 1.3A (핀당 0.33A, 정격 미확인 → O-17 게이트)
고속: EPHY MDI 100R · USB 90R · SDIO0 3.3V (P-002 넷클래스)
12V 입력 · 보호
DC 12V (GST25A12 2.08A) → F1 3A → Q1 역접 P-FET → D2 SMBJ15A (클램프 24.4V)
12V_IN 최악 1.84A (계약 3.2절 v1.2)
5V 강압 TPS54302 (5V_SYS → 코어 VIN)
Vout = 0.596 x (1 + 100k/13.3k) = 5.08V · 3A급, 예산 피크 1.3A (계약 3.1절)
TI SLVSDG6C 7.2 예: L 10uH, EN 개방 = 켬
12V_IR eFuse TPS26600 (IR LED 전원)
SHDN = IR_LED_EN (1.8V GPIO, 10k 풀다운 = 기본 끔) · UVLO = IN · OVP/MODE/RTN = GND (O-21)
ILIM 6.04k = 약 1.99A (C-018/O-91: 12V_IR 피크 1.585A×1.15 ≤ I(OL) 최소 1.86A, 분기 C2-4) · dVdT 22nF
USB-C (디바이스, 데이터 + VBUS 검출)
VBUS는 5V_SYS와 분리 (계약 C4) · USB_DET = VBUS / 3 (20k/10k)
D+/D- 90R (USB_90)
microSD (SDIO0, 3.3V 전용)
SD0_PWR_EN High = 켬 (gpio494) · CD = gpio493 (계약 7절)
R13~R17 풀업 DNP · U4/U5 ESD
이더넷 HR911105A (내장 마그네틱)
EPHY MDI 100R (MDI_100) · 센터탭 C15/C16 DNP (R-004 P6)
실드 CHASSIS = 1M || 1nF/2kV → GND
보드 간 커넥터 · 디버그 UART · 버튼 · 상태 LED
보드 간 JST GH 6P 대칭 (계약 12A절 v1.3): 1/6 GND · 2/5 12V_IR · 3 SPARE1 · 4 ALS_INT_RSV
디버그 TX = 부트 스트랩 (풀다운·LED 금지) · UPGRAD_KEY 직렬 1k (C16)
시험점 (계약 11절)
PWR_FLAG (ERC: 전원 입력 핀이 있는데 구동원이 없는 넷)

Board: 4 copper layers, 40.0 x 54.0 mm, 103 parts (42 on the bottom side), 57 nets.

Other parts of the board:
H1, H2, H3, H4: M1.6; MountingHole_M1.6_NPTH

## Code that names these connections

File hardware/schematic/tools/boards.py (part):

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s = Sheet('carrier', 'OpenHW carrier board (rear) - reCamera Core 2002 J2 mate', LOCAL, power=('GND','12V_IN','5V_SYS','12V_IR','CORE_3V3','SD_PWR_3V3','CHASSIS'))
s.block('BTB','코어 BTB (J2 짝, ST-BTB-058060-A / HCTL)',['계약 4절 핀맵 · 짝 핀 홀짝 반전 · VIN 4핀 = 5V_SYS 피크 1.3A (핀당 0.33A, 정격 미확인 → O-17 게이트)','고속: EPHY MDI 100R · USB 90R · SDIO0 3.3V (P-002 넷클래스)'],cols=1)
ren = {'VIN': '5V_SYS', '+3V3': 'CORE_3V3', 'MIPI_TXM2/IIC1_SDA/PWM': 'I2C1_SDA', 'MIPI_TXP2/IIC1_SCL/PWM': 'I2C1_SCL',
       'MIPI_TXM1/IIC2_SDA/PWM': 'SPARE1', 'MIPI_TXP1/IIC2_SCL/PWM': 'IR_LED_EN', 'MIPI_TXM0/GPIO12/PWM': 'STATUS_LED',
       'PWR_WAKEUP1': 'ALS_INT_RSV', 'BT_UART1_RX': 'UART1_RX', 'BT_UART1_TX': 'UART1_TX', 'BT_UART1_CTS': 'UART1_CTS', 'BT_UART1_RTS': 'UART1_RTS'}
bm = btb_nets(f'{NETX}/b101.xml')
nets = {}
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s.add('D7', 'Device:D_Zener', 'SMBJ6.0A', 'Diode_SMD:D_SMB', {'1': '5V_SYS', '2': 'GND'}, fields={'MPN': 'SMBJ6.0A (VRWM 6.0V > Vout max 5.30V, V-004b R5)', 'Note': 'unidirectional TVS, K=1'})
s.add('D3', 'Device:LED', 'PWR green', 'LED_SMD:LED_0603_1608Metric', {'2': 'PWR_LED_A', '1': 'GND'})
R(s, 'R4', '2.2k', '5V_SYS', 'PWR_LED_A')
s.block('EFUSE','12V_IR eFuse TPS26600 (IR LED 전원)',['SHDN = IR_LED_EN (1.8V GPIO, 10k 풀다운 = 기본 끔) · UVLO = IN · OVP/MODE/RTN = GND (O-21)','ILIM 6.04k = 약 1.99A (C-018/O-91: 12V_IR 피크 1.585A×1.15 ≤ I(OL) 최소 1.86A, 분기 C2-4) · dVdT 22nF'],cols=4)
# --- 12V_IR eFuse TPS26600 (O-21, V-002: SHDN + 10k pulldown, UVLO=IN, OVP/MODE=RTN, ILIM per 2 strings)
s.add('U2', 'Power_Management:TPS26600PWP', 'TPS26600PWPR', 'Package_SO:HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.66x2.46mm',  # C-018/O-86 #21: thermal vias placed by pcb (d0.3)
      {'1': '12V_IN', '2': '12V_IN', '3': '12V_IN', '5': 'GND', '7': 'IR_LED_EN', '8': 'GND', '9': 'GND', '11': 'EFUSE_ILIM', '12': 'EFUSE_DVDT', '15': '12V_IR', '16': '12V_IR', '17': 'GND'},
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R(s, 'R9', '200k', 'USB_VBUS', 'USB_DET'); R(s, 'R10', '100k', 'USB_DET', 'GND')
C(s, 'C22', '10nF', 'USB_DET', 'GND')
C(s, 'C12', '1uF', 'USB_VBUS', 'GND')
s.block('SD','microSD (SDIO0, 3.3V 전용)',['SD0_PWR_EN High = 켬 (gpio494) · CD = gpio493 (계약 7절)','R13~R17 풀업 DNP · U4/U5 ESD'],cols=4)
# --- microSD (SD0, 3.3V only, B101-equivalent power switch re-drawn)
s.add('J4', 'Connector:Micro_SD_Card_Det_Hirose_DM3AT', 'DM3AT-SF-PEJM5', 'Connector_Card:microSD_HC_Hirose_DM3AT-SF-PEJM5',
      {'1': 'SDIO_D2', '2': 'SDIO_D3', '3': 'SDIO_CMD', '4': 'SD_PWR_3V3', '5': 'SDIO_CLK', '6': 'GND', '7': 'SDIO_D0', '8': 'SDIO_D1', '9': 'SDIO_CD', '10': 'GND', 'SH': 'GND'},
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f = Sheet('front', 'OpenHW front (sensor) board - reCamera Core 2002 J1 mate', LOCAL, power=('GND','VIN','12V_IR','CORE_3V3','CORE_1V8','FRONT_2V8','CAM_1V8'))
fm = btb_nets(f'{NETX}/s401.xml')
f.block('BTB','코어 BTB (J1 짝, ST-BTB-058060-B / HCTL, 전면 보드 아랫면)',['계약 5절 핀맵 · CSI 2레인 (CLK=RX2, D0=RX0, D1=RX3) 100R · I2C2 1.8V','VIN 4핀 (코어 5V) · CORE_1V8 300mA · CORE_3V3 1A (코어와 공유)'],cols=1)
fren = {'VIN': 'VIN', '1V8': 'CORE_1V8', '3V3': 'CORE_3V3', 'GPIO15/IR_CUT': 'IR_CUT'}
nets = {}
for p in range(1, 61):
    n = fm.get(str(p), '')
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f.add('J1', 'Connector_Generic:Conn_02x30_Odd_Even', 'HC-PBB05-2-60-F-H4.0 (ST-BTB-058060-B)', 'openhw:BTB_ST-BTB-058060-B_2x30_P0.5mm', nets,
      fields={'MPN': 'HCTL HC-PBB05-2-60-F-H4.0-G1-R-P-04 / alt SUNGTECH ST-BTB-058060-B', 'Note': 'mates core J1 (bottom side of front board); O-17 gate'})
report['front_btb'] = nets
f.block('LDO','전면 2.8V LDO (RT9013-28, C-004 R9)',['VIN 5V → FRONT_2V8 (DRV8837 VCC: VIH max 0.5×2.8 = 1.4V → 1.8V GPIO 여유 0.4V · LTR-329 VDD 2.4~3.6V)'],cols=4)
# --- front 3.3V LDO (RT9013-33GB; AP2112K symbol has same SOT-23-5 pinout 1 VIN 2 GND 3 EN 5 VOUT)
f.add('U1', 'Regulator_Linear:AP2112K-3.3', 'RT9013-28GB', 'Package_TO_SOT_SMD:SOT-23-5', {'1': 'VIN', '2': 'GND', '3': 'VIN', '5': 'FRONT_2V8'},
      fields={'MPN': 'Richtek RT9013-28GB (stock check pending)', 'Note': 'symbol AP2112K has same SOT-23-5 pinout; pin4 = NC (DS9013, V-004 R12)'})
C(f, 'C1', '1uF', 'VIN', 'GND'); C(f, 'C2', '1uF', 'FRONT_2V8', 'GND')
f.block('ICR','ICR 구동 DRV8837 + CLA216-ICR',['VM = VIN 5V · VCC = 2.8V (C-004 R9) · IN1 = IR_CUT (gpio495) · IN2 = WH_PWM (gpio352)','코일 20R 약 0.245A, 펄스 100~500ms (FW) · 기본 IN1 = IN2 = 0 (계약 C13)'],cols=4)
# --- ICR driver DRV8837 (C13): VM=VIN 5V, VCC=FRONT_3V3, IN1=IR_CUT, IN2=WH_PWM
f.add('U2', 'Driver_Motor:DRV8837', 'DRV8837DSGR', 'openhw:Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm',
      {'1': 'VIN', '2': 'ICR_A', '3': 'ICR_B', '4': 'GND', '5': 'WH_PWM', '6': 'IR_CUT', '7': 'ICR_NSLEEP', '8': 'FRONT_2V8', '9': 'GND'},
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    C(f, f'C{15 if k=="A" else 17}', '100nF/50V', '12V_IR', 'GND', dnp=dn)
f.block('FPC','보드 간 JST GH 6P (직선 케이블 J7-n ↔ J4-(7−n), O-41)',['계약 12A절 v1.8 · 3 ALS_INT_RSV · 4 SPARE1 (캐리어와 3·4 맞바꿈) · 12V_IR 2접점 x 1.0A'],cols=3)
# FPC 10P (symmetric, mirror of carrier J7)
f.add('J4', 'Connector_Generic_MountingPin:Conn_01x06_MountingPin', 'JST GH 6P (board link)', 'Connector_JST:JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal', {**fpc, '3': 'ALS_INT_RSV', '4': 'SPARE1'},
      fields={'MPN': 'JST SM06B-GHS-TB', 'Note': 'C-009/O-41: straight cable J7-n <-> J4-(7-n) (both -X entry, U-bend); pins 3/4 swapped vs carrier J7'})
# C-016/O-83: R15 10k ALS_INT_RSV pull-up removed (J2-32 unconnected, LTR-329ALS-01 has no INT; ALS_INT_RSV = harness spare only)
f.block('TP','시험점 (계약 11절)',cols=9)
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