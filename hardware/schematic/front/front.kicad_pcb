# Repository ghlee0786/OpenHW

File README.md:

<!-- 수치는 저장소 결과 파일에서 읽은 값이다(기준 커밋 main 995b872, 2026-11-27). 값마다 출처 경로를 표 각주와 docs/readme/*.svg 주석에 적었다. -->

<div align="center">

# OpenHW

**SG2002 엣지 AI 카메라 — 직접 설계한 PCB 두 장과 구매한 코어 모듈, 렌즈·IR-cut·IR 조명을 한 몸으로**

</div>

> **English summary**
> OpenHW is an open-hardware edge-AI camera proof of concept built around the SG2002 SoC.
> A purchased core module (reCamera Core 2002) sits between two boards we designed in KiCad 10:
> a 40×40 mm front board (image sensor, M12 lens, IR-cut filter, 850 nm IR LEDs, ambient light sensor)
> and a 40×54 mm carrier board (12 V input and protection, 5 V buck, 10/100 Ethernet, USB-C, microSD).
> The device runs Linux and detects people on the on-chip NPU.
> The project is in the virtual-design stage: schematics pass ERC with zero violations, 25 of 25 circuit simulations pass,
> and both boards pass DRC with zero violations and zero unconnected items.
> Hardware design files are released under the Apache License 2.0.

## 진행 상태

| 단계 | 상태 | 근거 (결과 파일) |
|---|---|---|
| 제품 기획 · 작업 기본값 | ✅ 완료 | [`product-brief.md`](docs/planning/product-brief.md) · [`D-003`](docs/decisions/D-003-working-defaults.md) |
| 회로도 2장 | ✅ ERC 위반 0 | [`carrier-erc.json`](hardware/schematic/carrier/carrier-erc.json) · [`front-erc.json`](hardware/schematic/front/front-erc.json) |
| 회로 시뮬레이션 | ✅ 25/25 통과 (ngspice-47) | [`hardware/sim/results/`](hardware/sim/results) |
| 전면 보드 PCB | ✅ DRC 위반 0 · 미연결 0 · 회로도 일치 0 | [`front-drc.json`](hardware/pcb/drc/front-drc.json) |
| 캐리어 보드 PCB | ✅ DRC 위반 0 · 미연결 0 · 회로도 일치 0 | [`carrier-drc.json`](hardware/pcb/drc/carrier-drc.json) |
| 3D 조립 판정 | ✅ 보드 995b872 + 케이스 시안 A: 27항목 불합격 0 · 간섭 0 | [`run_A.md`](mechanical/m010/run_A.md) · [`judge.md`](mechanical/m007/judge.md) |
| 케이스 | ✅ 시안 A 상세 설계 (54 × 75.5 × 71.7 mm, 앞 스모크 유리 · 뒤 알루미늄 방열 쉘) | [`o126_a.md`](mechanical/design/o126_a.md) · [`o126_thermal.md`](mechanical/design/o126_thermal.md) |
| 최종 렌더 | ✅ 시안 A 6컷 + 회전 영상 — 사실감 · 유리 너머 기판 비침 · 브래킷 광축 사용자 확인 완료(2026-11-28) | [`docs/renders/final/`](docs/renders/final) |
| 실물 제작 | ⏳ 이번 범위(가상 설계) 밖 | — |

## 주요 기능

- **사람 감지를 보드 안에서** — SG2002의 NPU에서 YOLOX-Nano(BF16)를 돌린다. 영상을 밖으로 보내지 않고 감지 이벤트만 보낸다. ([D-003](docs/decisions/D-003-working-defaults.md) #3 #8 #19)
- **주야 자동 전환** — 조도센서로 밤낮을 판단해 IR-cut 필터를 바꾸고, 850 nm IR LED를 켠다. LED는 듀티와 피크를 펌웨어로 제한한다. ([D-003](docs/decisions/D-003-working-defaults.md) #6 #7 #26)
- **12 V 한 줄 입력** — 퓨즈·역접속 보호 뒤 5 V 강압으로 코어를 먹이고, IR 조명 갈래는 eFuse로 전류를 제한한다. ([D-003](docs/decisions/D-003-working-defaults.md) #10 #22)
- **유선 이더넷 10/100 · USB-C · microSD** — 네트워크 서비스는 닫힌 상태가 기본이다. ([D-003](docs/decisions/D-003-working-defaults.md) #11 #30)
- **광학 일체 설계** — M12 렌즈 광축·IR LED 위치·조도 창을 PCB 배치 기준으로 삼았다. ([D-003](docs/decisions/D-003-working-defaults.md) #4 #17)

## 아키텍처

### 3층 적층

캐리어 보드(아래) – 코어 모듈 – 전면 보드(위)를 0.5 mm 60핀 BTB 커넥터 두 쌍으로 바로 꽂는다(결합 높이 8.0 mm). 전면과 캐리어 사이 IR 전원·제어는 GH 6핀 하니스로 잇는다.

<p align="center"><br><sub>실제 보드 파일로 쌓은 3층 적층 회전 (KiCad 3D 렌더)</sub></p>

### 시스템 블록도

## 갤러리

### 3D — 전면 보드

<table>
<tr>
<td align="center" width="33%"><br><sub>비스듬한 앞면 — 렌즈 홀더·IR LED</sub></td>
<td align="center" width="33%"><br><sub>비스듬한 뒷면 — BTB·열 패드</sub></td>
<td align="center" width="33%"><br><sub>360° 회전</sub></td>
</tr>
<tr>
<td align="center"><br><sub>윗면</sub></td>
<td align="center"><br><sub>아랫면</sub></td>
<td align="center"><sub>캐리어 보드 3D는 아래 표<br>3층 적층 회전은 <a href="#3층-적층">아키텍처</a></sub></td>
</tr>
</table>

### 3D — 캐리어 보드

<table>
<tr>
<td align="center" width="33%"><br><sub>비스듬한 윗면 — BTB·5 V 강압·USB-C</sub></td>
<td align="center" width="33%"><br><sub>비스듬한 뒤쪽 — RJ45·DC 잭·microSD</sub></td>
<td align="center" width="33%"><br><sub>360° 회전</sub></td>
</tr>
<tr>
<td align="center"><br><sub>윗면 — 누르면 큰 그림</sub></td>
<td align="center"><br><sub>아랫면 — 누르면 큰 그림</sub></td>
<td align="center"><sub>캐리어 40 × 54 mm · 4층<br>DRC 위반 0 · 미연결 0<br>(<a href="hardware/pcb/drc/carrier-drc.json">carrier-drc.json</a>)</sub></td>
</tr>
</table>

### 전면 보드 PCB 층 (4층)

<table>
<tr>
<td align="center"><br><sub>F.Cu — 윗면 신호</sub></td>
<td align="center"><br><sub>In1.Cu — GND 기준면</sub></td>
<td align="center"><br><sub>In2.Cu — GND · 전원</sub></td>
</tr>
<tr>
<td align="center"><br><sub>B.Cu — 아랫면 신호</sub></td>
<td align="center"><br><sub>실크</sub></td>
<td align="center"><sub>규칙: 트랙/간격 0.15/0.16 mm 이상<br>고속 차동 100 Ω · USB 90 Ω<br>(<a href="docs/decisions/D-003-working-defaults.md">D-003</a> #21)</sub></td>
</tr>
</table>

### 회로도

<table>
<tr>
<td align="center" width="50%"><br><sub>전면 보드 — 누르면 원본 SVG</sub></td>
<td align="center" width="50%"><br><sub>캐리어 보드 — 누르면 원본 SVG</sub></td>
</tr>
</table>

### 회로 시뮬레이션 파형

캐리어 전원 계열 **15/15**(SIM-A·B·C·D), 전면 보드 **10/10**(SIM-L) 통과 — [`hardware/sim/results/`](hardware/sim/results)

<table>
<tr>
<td align="center" width="50%"><br><sub>SIM-D1 전원 순서 전체 기동 (12 V → 5 V → 코어 → 전면 2.8 V)</sub></td>
<td align="center" width="50%"><br><sub>SIM-B4 5 V 강압 기동 (소프트 스타트 5 ms)</sub></td>
</tr>
<tr>
<td align="center"><br><sub>SIM-L1 IR LED 한 줄 전류 · 리플 · 주파수</sub></td>
<td align="center"><br><sub>SIM-L10 카메라 전원 켜는 순서 (IOVDD → AVDD ≥ 50 µs)</sub></td>
</tr>
</table>

### 케이스 — 시안 A 최종 렌더

<p align="center"><br><sub>콘셉 영상 — 분해에서 조립까지 · Concept film — from exploded parts to the assembled camera (누르면 1080p MP4)</sub></p>

> 둥근 박스 54 × 75.5 × 71.7 mm · 앞면 스모크 유리(가시광 투과 약 15 %, 안쪽 검정 마스크) · 뒤쪽 알루미늄 방열 쉘 + 무광 흑색 플라스틱 · 벽 브래킷. 누르면 1600 px 원본. 근거: [시안 A 설계](mechanical/design/o126_a.md) · [조립 판정 기록](mechanical/m010/run_A.md)

<table>
<tr>
<td align="center" width="33%"><br><sub>제품 — 비스듬한 앞쪽</sub></td>
<td align="center" width="33%"><br><sub>정면 — 스모크 유리 · 렌즈 창</sub></td>
<td align="center" width="33%"><br><sub>뒤쪽 — 알루미늄 방열 핀</sub></td>
</tr>
<tr>
<td align="center" width="33%"><br><sub>분해도 — 쉘 · 보드 · 유리</sub></td>
<td align="center" width="33%"><br><sub>단면 — 내부 적층</sub></td>
<td align="center" width="33%"><br><sub>설치 — 벽 브래킷, 광축 수평</sub></td>
</tr>
</table>

#### 영상 · Videos

<table>
<tr>
<td align="center" width="50%"><br><sub>360도 회전 · 360° turntable</sub></td>
<td align="center" width="50%"><br><sub>단면 열림 — 내부 적층 · Section opening — inside the stack</sub></td>
</tr>
<tr>
<td align="center" width="50%"><br><sub>카메라 이동 — 제품 히어로 · Hero dolly shot</sub></td>
<td align="center" width="50%"><br><sub>브래킷 팬 · 틸트 · Wall bracket pan &amp; tilt</sub></td>
</tr>
</table>

<sub>렌더 · 영상 속 코어 모듈 형상은 원 설계에서 가져왔고, 이 렌더 · 영상 파일은 CC BY-SA 4.0이다 — 출처 [NOTICE](docs/renders/final/NOTICE.md) · The core-module geometry in these renders and videos comes from the original design; these render and video files are CC BY-SA 4.0 — see [NOTICE](docs/renders/final/NOTICE.md).</sub>

## 기술 스택

| 분야 | 도구 · 구성 | 근거 |
|---|---|---|
| 회로도 · PCB | KiCad 10 (`kicad-cli`로 ERC · DRC · STEP · 렌더 · 그림 내보내기) | [`hardware/schematic/`](hardware/schematic) |
| 회로 시뮬레이션 | ngspice-47, 넷리스트와 판정 스크립트 | [`hardware/sim/README.md`](hardware/sim/README.md) |
| PCB 규칙 | 4층 1.6 mm, 넷클래스 + 사용자 DRC 규칙 | [`hardware/pcb/rules/`](hardware/pcb/rules) |
| 기구 | STEP 기반 3D 조립 판정 스크립트, 케이스 매개변수 설계 | [`mechanical/`](mechanical) |
| 펌웨어 | Buildroot Linux (벤더 커널 5.10.4), 사람 감지·주야 전환 앱 | [`firmware/`](firmware) |
| AI 모델 | YOLOX-Nano → NPU용 BF16 모델 변환 | [D-003](docs/decisions/D-003-working-defaults.md) #19 |
| 검사 자동화 | Python 스크립트 — 종료 코드 = 불합격 수 | [검증 방법](#사용법) |

## 사양

| 항목 | 전면 보드 | 캐리어 보드 | 코어 모듈 (구매품) |
|---|---|---|---|
| 크기 | 40 × 40 mm | 40 × 54 mm | — |
| 층 · 두께 | 4층 · 1.6 mm | 4층 · 1.6 mm | — |
| 주요 부품 | 이미지 센서 모듈 GC2053 (2 MP, MIPI CSI, 24핀 BTB) · 24 MHz 발진기 · IR-cut 구동 DRV8837 · IR LED 구동 AL8860 ×2 · 850 nm IR LED 자리 4개 (2직렬 × 2줄, PoC는 1줄 실장) · 조도센서 LTR-329 · 2.8 V LDO | 12 V DC 잭 · 퓨즈·역접속 보호 · eFuse TPS26600 (IR 전원) · 5 V 강압 TPS54302 · RJ45 10/100 · USB-C · microSD · 디버그 UART · ESD 보호 | SG2002 SoC (NPU) · 8 GB |
| 보드 간 연결 | BTB 60핀 (암) · GH 6핀 | BTB 60핀 (수) · GH 6핀 | BTB 60핀 ×2 |
| 풋프린트 수 | 100 (시험점 포함) | 103 (시험점 포함) | — |

| 시스템 | 값 |
|---|---|
| 입력 전원 | 12 V DC |
| 네트워크 | 유선 이더넷 10/100 |
| 저장 | 이벤트 전송 기본 + microSD 슬롯 |
| 운영체제 | Linux (벤더 커널 5.10) |
| 감지 | 사람 감지 — YOLOX-Nano, NPU용 BF16 모델 |
| 렌즈 | M12 고정초점, 수평 화각 약 90° |
| BTB 결합 높이 | 8.0 mm |

출처: [D-003 작업 기본값](docs/decisions/D-003-working-defaults.md) #1 #4 #5 #7 #8 #10 #11 #15 #17 #19 #21 #25 #44 · 보드 파일 [`carrier.kicad_pcb`](hardware/schematic/carrier/carrier.kicad_pcb) · [`front.kicad_pcb`](hardware/schematic/front/front.kicad_pcb)(부품 값·풋프린트 수·층 수) · [`params.md`](mechanical/m003/params.md)(btb_h 8.0)

## 저장소 구조

| 폴더 | 내용 |
|---|---|
| [`hardware/schematic/`](hardware/schematic) | KiCad 프로젝트 2개(`carrier/`, `front/`) — 회로도·PCB·ERC 결과 |
| [`hardware/pcb/`](hardware/pcb) | PCB 규칙·DRC 결과·STEP·배치 계획과 배선 도구 |
| [`hardware/libraries/`](hardware/libraries) | 프로젝트 심벌·풋프린트 라이브러리와 파생 고지 |
| [`hardware/sim/`](hardware/sim) | 회로 시뮬레이션 넷리스트·결과·파형 |
| [`hardware/datasheets/`](hardware/datasheets) | 공개 라이선스 데이터시트·참고 설계 원본과 [목록](hardware/datasheets/INDEX.md) |
| [`firmware/`](firmware) | Linux 이미지 패치·앱(사람 감지, 주야 전환)·모델 |
| [`mechanical/`](mechanical) | 적층 기준 모델·조립 판정·케이스 설계 |
| [`docs/`](docs) | 기획(`planning/`), 결정(`decisions/`), 조사(`research/`), 검토(`review/`), 렌더(`renders/`), 이 README의 그림(`readme/`) |
| [`manufacturing/`](manufacturing) | 부품표(BOM) 정리 |
| [`validation/`](validation) | 독립 검토 기록 |

그 밖의 점(.)으로 시작하는 폴더와 자동화 폴더는 작업 환경 설정이며 설계 내용이 아니다.

## 사용법

### KiCad로 열기

1. KiCad 10을 설치한다.
2. `hardware/schematic/front/front.kicad_pro` 또는 `hardware/schematic/carrier/carrier.kicad_pro`를 연다.
3. 프로젝트 라이브러리는 각 프로젝트의 `fp-lib-table`·`sym-lib-table`이 저장소 안 경로로 잡는다.

### 검증 방법

모든 판정은 도구의 종료 코드와 결과 파일로 한다. 그림이나 의견으로 통과를 정하지 않는다.

| 검사 | 명령 (저장소 루트) | 결과 파일 |
|---|---|---|
| ERC | `kicad-cli sch erc --severity-all --exit-code-violations --format json -o hardware/schematic/front/front-erc.json hardware/schematic/front/front.kicad_sch` | `hardware/schematic/*/*-erc.json` |
| DRC | `kicad-cli pcb drc --format json --severity-all --schematic-parity --exit-code-violations -o hardware/pcb/drc/front-drc.json hardware/schematic/front/front.kicad_pcb` | `hardware/pcb/drc/*-drc.json` |
| 회로 시뮬레이션 | [`hardware/sim/README.md`](hardware/sim/README.md)의 실행 방법 (종료 코드 = fail + error 수) | `hardware/sim/results/SIM-*.json` |
| 3D 조립 판정 | `python -I -B mechanical/m007/run_all.py` (종료 코드 = 불합격 수) | [`mechanical/m007/judge.md`](mechanical/m007/judge.md) |
| README 그림 | `python -I docs/readme/tools/make_svgs.py` 후 `python -I docs/readme/tools/check_readme.py` (종료 코드 = 실패 수) | `docs/readme/*.svg` |

캐리어는 위 명령의 `front`를 `carrier`로 바꾼다. ERC·DRC는 위반이 있으면 종료 코드가 0이 아니다.

## 문서

| 문서 | 내용 |
|---|---|
| [제품 기획](docs/planning/product-brief.md) | 용도·형태·미정 항목 |
| [D-003 작업 기본값](docs/decisions/D-003-working-defaults.md) | 설계 갈림길마다 「분기점 · 선택 · 이유 · 차선책」 50여 개 |
| [D-001 SoC 선택](docs/decisions/D-001-soc.md) · [D-002 모듈 + 캐리어 구조](docs/decisions/D-002-module-carrier.md) | 구조 결정 |
| [HW/FW 인터페이스](docs/decisions/hw-fw-interface.md) | 핀·버스·전원 계약 |
| [PCB 배치 계획](hardware/pcb/layout-plan.md) | 보드 배치·적층 기준 |
| [시뮬레이션](hardware/sim/README.md) | 시뮬레이션 실행 방법과 결과 |
| [3D 조립 판정](mechanical/m007/m007-assembly.md) · [케이스 시안 A](mechanical/design/o126_a.md) | 기구 판정과 케이스 상세 설계 |
| [PCB 독립 검토](docs/review/v005-pcb-review.md) | 규칙·완화 검토 |
| [데이터시트 목록](hardware/datasheets/INDEX.md) | 출처·리비전·sha256 |

## 라이선스 · 제3자 고지

- 이 저장소의 설계 파일과 문서는 [Apache License 2.0](LICENSE)을 따른다. 예외: 코어 모듈 형상이 들어간 렌더 · 영상 파일(아래 표).
- 제3자 자료는 각 폴더의 라이선스를 그대로 유지한다. 저작권 표기는 각 폴더의 `LICENSE*` 파일 원문을 따른다. 근거는 [`hardware/datasheets/INDEX.md`](hardware/datasheets/INDEX.md)다.

| 경로 | 라이선스 | 비고 |
|---|---|---|
| `hardware/datasheets/sophgo/` | BSD 2-Clause | SG2002 데이터시트·TRM·참고 회로도 원본 |
| `hardware/datasheets/seeed/` | Apache 2.0 (저장소) · 코어 회로도 PDF는 CC BY-SA 4.0 | 참고 전용 원본. 수정하지 않았다 |
| `hardware/datasheets/antmicro/` | Apache 2.0 | 참고 풋프린트 원본 |
| `hardware/libraries/` 파생 풋프린트 | Apache 2.0 | 원저작물 고지는 [`hardware/libraries/README.md`](hardware/libraries/README.md) · [`licenses/Apache-2.0.txt`](hardware/libraries/licenses/Apache-2.0.txt) |
| 사람 감지 모델 YOLOX-Nano | Apache 2.0 | [D-003](docs/decisions/D-003-working-defaults.md) #19 |
| `docs/renders/final/` · `video/` · `docs/readme/gallery/case-a/` 렌더 · 영상 | CC BY-SA 4.0 | 코어 모듈 형상(STEP, 저장소에는 넣지 않음)의 출처 · 커밋 · 바꾼 것은 [`NOTICE.md`](docs/renders/final/NOTICE.md) · Core-module geometry source and changes: see NOTICE |

라이선스가 표기되지 않았거나 배포가 제한된 데이터시트는 저장소에 넣지 않았고, 링크와 sha256만 [INDEX.md](hardware/datasheets/INDEX.md)에 남겼다.

<div align="center"><sub>그림은 움직이는 SVG다. 운영체제에서 「동작 줄이기」를 켜면 멈춘 그림으로 보이고, 밝은·어두운 테마를 따른다.</sub></div>

## KiCad design hardware/schematic/front/front.kicad_pcb

File hardware/schematic/README.md (part):

# C-002 회로도 — 캐리어 보드 · 전면(센서) 보드

- 배정: orch t18r C-002 (README 단계 4) + G-001(GUI) · 작성: schematic · 레인 `t-20261126-165741-b193` (L-001 `t-20261126-161205-dcb9`에서 이어 받음) · 2026-11-26
- 상태: **회로도 초안 — ERC 0**. PCB(`*.kicad_pcb`)는 P-003에서 pcb 역할이 이 폴더로 가져온다(O-20).
- **계약:** `hw-fw-contract.md` v1.2 (C-001 레인 `t-20261126-155208-d030`, 커밋 `fd12ba4`). 이 회로도에 맞춰 v1.2로 함께 고쳤다(13절).
- **입력:**
  - L-001 라이브러리 (`hardware/libraries`, 이 레인에 포함)
  - P-002 넷클래스 (`022c364`)
  - M-001b/c 높이·배치 (`fd9ed82`·`4dc801d`)
  - R-004 BOM (`7a9923c`), V-002 (`51489c5`), R-006 (`67e9959`)
  - orch O-16~O-26

## 1. 파일

| 파일 | 내용 |
|---|---|
| `carrier/carrier.kicad_pro` · `carrier.kicad_sch` | 캐리어(뒤, 코어 J2 짝) 프로젝트와 회로도 |
| `front/front.kicad_pro` · `front.kicad_sch` | 전면(센서, 코어 J1 짝) 프로젝트와 회로도 |
| `*/sym-lib-table` · `*/fp-lib-table` | 프로젝트 라이브러리 `openhw` → `../../libraries/` |
| `carrier/carrier.net` · `front/front.net` | `kicad-cli sch export netlist` 결과 (KiCad S-expression) |
| `carrier/carrier-erc.json` · `front/front-erc.json` | `kicad-cli sch erc` 결과 |
| `tools/schgen.py` · `boards.py` · `symlib.py` | 회로도 생성기 (2절) |

- `*.kicad_prl`(로컬 화면 상태)은 커밋하지 않는다.

## 2. 작성 방법

- **방식:**
  - `tools/boards.py`에 부품·핀·넷을 적었다. `tools/schgen.py`가 KiCad 10 공식/프로젝트 라이브러리 심벌을 회로도에 넣는다.
  - 연결 방식: 각 핀 끝에 **넷 라벨**을 붙이고, 쓰지 않는 핀에는 **NC 표시**를 한다.
  - 전원 입력 핀이 있는데 구동원이 없는 넷에는 **PWR_FLAG**를 자동으로 단다.
    - 캐리어: 12V_IN · GND · SD_PWR_3V3
    - 전면: 12V_IR · CORE_1V8 · GND · VIN
  - (C-002 초안) 선(wire) 없이 부품 격자 배치였다. C-002b부터 기능 블록 배치 + 블록 안 배선이다(2A절).
- **BTB 60핀 넷:** Seeed B101/S401 넷리스트(인터페이스 사실, Apache-2.0)를 읽어 계약 4·5절 이름 규칙으로 바꿔 만들었다. 손으로 옮겨 적지 않았다. 대조 결과는 6절에 있다.
- **GUI(G-001):** KiCad 10.0.8 회로도 편집기로 두 프로젝트를 열어 확인했고, GUI에서 ERC도 돌렸다(9절 스크린샷).
  - 편집은 「파일 생성 → GUI로 불러 확인」 방식이다. GUI에서 저장하지 않았다.
  - 실험적 MCP 회로도 편집은 쓰지 않았다(KICAD_MCP_ENABLE_SCH_EDIT=0).
- **다음 편집:** 사람이 GUI에서 고치면 그 파일이 원본이 된다. 생성기를 다시 돌리면 GUI 편집을 덮어쓰므로, 그 뒤에는 생성기를 쓰지 않는다.

## 2A. C-002b 가독성 정리 (lead 분기 O-28)

- **방식:** 시트 하나 안에 기능 블록을 둔다. 계층 시트로 나누지 않은 이유는 로컬 라벨이 `/시트/넷`으로 바뀌어 넷 이름이 달라지기 때문이다(분기 C2b-1).
  - 블록마다 점선 틀, 제목, 주석 1~2줄(전압·전류·계약 절)을 둔다.
  - 부품은 블록 안에 신호 순서대로 놓는다.
  - 블록 글자는 「Malgun Gothic」으로 지정했다. KiCad 기본 글꼴에는 한글이 없다.
- **블록:**
  - 캐리어: 코어 BTB · 12V 입력·보호 · 5V 강압 · 12V_IR eFuse · USB-C · microSD · 이더넷 · FPC·디버그·버튼·LED · 시험점 · PWR_FLAG
  - 전면: 코어 BTB · 전면 3.3V LDO · ICR · 센서 DF30·24MHz·전원 스위치 · 조도·I2C 풀업 · IR LED 2스트링 · FPC · 시험점 · PWR_FLAG
- **배선 규칙:**
  - **블록 안에서만 쓰이는 넷**(전원 넷 제외)은 짧은 직교 배선으로 잇는다. 넷 이름을 지키려고 라벨을 하나 남긴다. → 캐리어 11넷(선 25개), 전면 5넷(선 12개).
  - 블록 사이 넷과 전원 넷(GND·12V_IN·5V_SYS·12V_IR·CORE_3V3·CORE_1V8·FRONT_3V3·VIN·SD_PWR_3V3·CHASSIS)은 핀마다 라벨을 둔다.
  - 배선이 다른 넷의 핀·선·NC 핀에 닿으면 생성기가 그 넷 전체를 라벨 방식으로 되돌린다. 우연히 이어지는 일을 막기 위해서다.
  - 아래 넷리스트 비교가 최종 판정이다.
- **참조 지정자:** 바꾸지 않았다(R1, U3 …, PCB 재연결 기준).
- **동일성 증명 (verifiable 예):**
  - 정리 전 = 커밋 `276fc89`의 `carrier.net`·`front.net`. 정리 후 = 이 커밋의 넷리스트.
  - 비교 스크립트: `tools/netcompare.py`
    - 부품마다 (참조, 값, 풋프린트)를 비교한다.
    - 넷마다 (이름, 핀 집합)을 비교한다.
    - 넷 이름의 시트 경로 접두어(`/`)만 무시한다.
    - 같으면 종료 0, 다르면 1.

| 비교 | 부품 | 넷 | 차이 | 종료 코드 |
|---|---|---|---|---|
| `python tools/netcompare.py <276fc89>/carrier.net carrier/carrier.net` | 91 / 91 | 93 / 93 | **0** | 0 |
| `python tools/netcompare.py <276fc89>/front.net front/front.net` | 78 / 78 | 64 / 64 | **0** | 0 |
| 음성 시험: front.net 사본에서 R1 값 하나와 C14 핀 하나를 바꿔 비교 | — | — | 3건 검출 | 1 |

- **ERC:** `kicad-cli sch erc --severity-all --exit-code-violations` → 캐리어 종료 0·위반 0, 전면 종료 0·위반 0.
- **그림 (verifiable 아니오, 사용자·lead 확인용):** `kicad-cli sch export svg` (종료 0, 파일 생성 확인)
  - `validation/runtime/kicad-gui/C-002b/carrier.svg` · `front.svg`
  - 미리보기 PNG: `carrier-preview.png` · `front-preview.png` · `*-preview-topleft.png`
- **GUI는 쓰지 않았다** (O-27, 소유권 pcb).

| # | 분기점 | 선택 | 이유 | 차선책 |
|---|---|---|---|---|
| C2b-1 | 계층 시트 vs 시트 안 블록 | 시트 안 블록 | 넷 이름(넷클래스 패턴·PCB 재연결)이 그대로 남는다 | 계층 시트 + 전역 라벨(넷 이름 유지는 되지만 시트 경로가 바뀐다) |
| C2b-2 | 블록 안 연결 | 자동 직교 배선 + 이름 라벨 1개, 충돌하면 라벨 방식 | 넷 동일성을 기계로 보장한다 | 사람이 GUI에서 배선 (pcb가 소유권을 돌려준 뒤) |
| C2b-3 | 한글 글꼴 | Malgun Gothic (Windows 기본) | KiCad 기본 스트로크 글꼴에 한글이 없다 | 블록 주석을 영문으로 |

## 3. 넷 이름 규칙 (P-002 넷클래스 패턴 · 계약 이름)

| 규칙 | 내용 | 넷클래스 |
|---|---|---|
| N1 | 코어 넷 이름을 기능 이름으로 바꾼다 (계약 4·5·7절 「용도」 열):<br>MIPI_TXM2/TXP2 → `I2C1_SDA/SCL`<br>MIPI_TXM1 → `SPARE1`<br>MIPI_TXP1 → `IR_LED_EN`<br>MIPI_TXM0 → `STATUS_LED`<br>PWR_WAKEUP1 → `ALS_INT_RSV`<br>BT_UART1_* → `UART1_*`<br>GPIO15/IR_CUT → `IR_CUT`<br>+3V3/3V3 → `CORE_3V3`<br>1V8 → `CORE_1V8`<br>캐리어 VIN → `5V_SYS` | `*3V3`·`*1V8` → PWR_LOGIC, `*5V_SYS` → PWR_5V |
| N2 | 고속선은 계약 이름 그대로: `CAM_RX0_*`, `EPHY_TX*/RX*`, `USB_DP/DN` | CSI_100 · MDI_100 · USB_90 |
| N3 | 12V 계열:<br>`12V_IN_RAW`(잭) → `12V_IN_F`(퓨즈 뒤) → `12V_IN`(역접 FET 뒤)<br>`12V_IR`(eFuse 출력, FPC) | 모두 `*12V_IN*` / `*12V_IR` 패턴 |
| N4 | 전면 VIN은 `VIN`(BTB 37~43 = 코어 VIN = 캐리어 5V_SYS) | PWR_5V (`VIN`) |

## 4. 캐리어 보드 블록

| 블록 | 부품 (레퍼런스) | 연결 핵심 | 근거 |
|---|---|---|---|
| 코어 짝 BTB | J1 `Conn_02x30_Odd_Even` / `openhw:BTB_ST-BTB-058060-A` | 6절 표 | 계약 4절, O-17·O-23(패드 0.25 원품 유지) |
| 12V 입력 | J2 DC 잭(XKB DC-005-5A-2.0), F1 3A, Q1 AO4407A(역접, 게이트 R1 100k·D1 12V 제너), D2 SMBJ15A, C1 47µ/25V, C2 10µ | 잭 → 퓨즈 → P-FET(D=입력, S=12V_IN) → TVS | 계약 12절 |
| 5V 벅 | U1 TPS54302 / L1 10µH / R2 100k / R3 13.3k / C3·C4 10µ, C5 100n, C6 BOOT 100n, C7·C8 22µ | EN 개방(내부 풀업), Vout = 0.596×(1+100/13.3) = 5.08V | TI SLVSDG6C §7.2 설계 예 (R2=100k, R3=13.3k, 10µH) |
| 전원 LED | D3 + R4 2.2k (5V_SYS) | — | — |
| 12V_IR eFuse | U2 TPS26600PWP | **SHDN ← IR_LED_EN + R5 10k 풀다운**, UVLO → IN, OVP·MODE·RTN·GND → GND, **ILIM R6 8.06k (≈1.49A)**, dVdT C9 22nF, FLT·IMON 개방 | O-21, V-002 ⑥, SLVSDG2G (「UVLO terminal must be connected to the IN terminal」, 「Designs that do not need reverse input polarity protection can have RTN, GND and PowerPAD connected together」, FLT·IMON 「If unused, leave floating」) |
| USB-C | J3 USB-C 16P(HRO TYPE-C-31-M-12), R7·R8 5.1k(CC), U3 USBLC6-2SC6, R9 20k / R10 10k → USB_DET | VBUS는 5V_SYS에 잇지 않음(C4), USB_DET = VBUS/3 | 계약 C4, B101과 같은 분압비 |
| microSD | J4 Hirose DM3AT, Q2 AO3401A + Q3 DMG1012T 스위치(SD0_PWR_EN High = 켬), R11·R12 100k, C13·C14, R13~R17 47k 풀업 **DNP**, U4·U5 TPD4E05U06 ESD | SD 3.3V 전용(DTS `no-1-8-v`), CD = gpio493 | 계약 5·7절, F-001 |
| 이더넷 | J5 HR911105A, C15·C16 센터탭 100n **DNP**, D4·D5 쌍별 TVS, R18 1M + C17 1nF/2kV (CHASSIS–GND) | EPHY_TXP/N → TD+/−, EPHY_RXP/N → RD+/−, 핀 8 → GND, 실드 → CHASSIS, LED 9~12 미사용 | R-004 P6-주의(센터탭 DNP), 계약 12절 |
| 디버그 UART | J6 JST SH 3P (GND·TX·RX) | TX에 풀다운·LED 없음(부트 스트랩) | 계약 10·11절 |
| 버튼 | SW1 RESET (nRESET→GND), SW2 UPGRADE (UPGRAD_KEY → R19 1k → 스위치), C18 10n | — | 계약 C16 |
| 상태 LED | Q4 DMG1012T(게이트 STATUS_LED, R20 100k) + D6 + R21 1.5k | 1.8V GPIO라 저문턱 NMOS | 계약 7절 |
| FPC | J7 TE 1-84952-0 (10P, 접점 1A) | 계약 12A절 핀배치(대칭) | R-004 P3, 계약 12A절 v1.2 |
| 시험점 | TP1~TP26 | 계약 11절 목록 + UART1·RESERVE·I2C1 | 계약 11절 |

## 5. 전면 보드 블록

| 블록 | 부품 | 연결 핵심 | 근거 |
|---|---|---|---|
| 코어 짝 BTB | J1 `Conn_02x30_Odd_Even` / `openhw:BTB_ST-BTB-058060-B` | 6절 표 | 계약 5절 |
| 3.3V LDO | U1 RT9013-33GB (심벌 `AP2112K-3.3` — SOT-23-5 핀 같음, 4번 BP 개방), C1·C2 1µ | VIN(5V) → FRONT_3V3 | R-004 U_3V3F |
| ICR | U2 DRV8837 (VM = VIN, VCC = FRONT_3V3, IN1 = IR_CUT, IN2 = WH_PWM, nSLEEP R1 10k → VCC), J2 JST 1.25mm 2P (CLA216), R2·R3 100k 풀다운 | 기본 IN1=IN2=0 (코스트) | 계약 C13 |
| 렌즈 홀더 | MH1 `openhw:M12_Holder_20mm_CLA216-ICR` (구멍 ±10, X축) | — | M-001c, R-006 O-26 |
| 센서 커넥터 | J3 DF30FC-24DS-0.4V(81) / `openhw:Hirose_DF30FC-24DS-0.4V_2x12_P0.4mm`(S401 파생) | 7절 표 | O-18, O-22, V-002 ④ |
| 카메라 전원 | Q1 AO3401A(IOVDD), Q2 AO3401A(AVDD, R5 10k + C6 100n **DNP** 지연), Q3 DMG1012T(게이트 CAM_EN), R4 100k, R6 100k, C7~C9 | CAM_EN=1 → CORE_3V3 → CAM_IOVDD·CAM_AVDD (모듈 3전원 모두 3.3V 입력, DVDD = J3-16 = AVDD 레일) | O-22, V-002 ④ (IOVDD 3.3V 전원 입력) |
| 센서 리셋 | R7 10k (CAM_EN → CAM_RESET), C10 100n **DNP** | RC 자리 | O-22 |
| MCLK | X1 OT7EL89 24MHz (OE = CAM_EN, VDD = CORE_1V8 상시), R8 22Ω, C11 | BTB에 MCLK 없음 → 발진기가 유일 경로 | 계약 9절, R-004 X_MCLK |

Parts (part):
C1, C2, C7, C8, C12, C18: 1uF; C_0402_1005Metric
C3: 10uF; C_0603_1608Metric
C4, C5, C9, C10, C11, C13: 100nF; C_0402_1005Metric
C6: 100nF; C_0402_1005Metric; not fitted
C14, C16: 10uF/50V X7R; C_1206_3216Metric
C15, C17: 100nF/50V; C_0402_1005Metric
C19, C20, C21: 4.7nF; C_0402_1005Metric
D1, D2: SS24 (40V 2A, SMA); D_SMA; MPN Vishay SS24S-E3/61T (SMA 40V 2A, LCSC C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
D3, D4, D5: BAT54WS; D_SOD-323
D_IR_A1: VSMA1085400; Vishay_VSMA1085600_3.4x3.4mm; MPN Vishay VSMA1085400 (+-40deg; package dr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
D_IR_A2: VSMA1085400; Vishay_VSMA1085600_3.4x3.4mm; MPN Vishay VSMA1085400
D_IR_B1: VSMA1085400; Vishay_VSMA1085600_3.4x3.4mm; MPN Vishay VSMA1085400 (+-40deg; package dr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

Connections (part):
/12V_IR: C14.1, C15.1, C16.1, C17.1, D1.1 (K), D2.1 (K), J4.2, J4.5, R13.1, R14.1, TP19.1, U4.8 (VIN), U5.8 (VIN)
/ALS_INT_RSV: J4.3, TP24.1
/CAM_1V8: C11.1, C18.1, C19.2, Q6.3 (D), R9.1, R10.1, R19.1, TP23.1, X1.1 (EN), X1.4 (Vdd)
/CAM_1V8_G: C19.1, Q6.1 (G), R17.2, R18.2
/CAM_1V8_PD: Q7.3 (D), R18.1
/CAM_AVDD: C8.1, C9.1, C21.2, J3.12, J3.16, Q2.3 (D), TP5.1
/CAM_EN: D3.1 (K), J1.48, Q3.1 (G), Q7.1 (G), R6.1, R7.1, TP8.1
/CAM_I2C2_SCL: J1.9, J3.3, R10.2, TP18.1, U3.4 (SCL)
/CAM_I2C2_SDA: J1.11, J3.1, R9.2, TP17.1, U3.3 (SDA)
/CAM_IOVDD: C7.1, C20.2, J3.14, Q1.3 (D), TP6.1
/CAM_MCLK: J3.4, R8.2, TP7.1
/CAM_PG: D4.1 (K), D5.2 (A), Q3.3 (D), R4.2, R5.1, R20.1
/CAM_PG_AV: C6.2, C21.1, D5.1 (K), Q2.1 (G), R5.2
/CAM_PG_IO: C20.1, Q1.1 (G), R20.2, R21.1
/CAM_PG_IOD: D4.2 (A), R21.2
/CAM_RESET: C10.1, D3.2 (A), J3.24, R7.2, R16.1, TP9.1
/CAM_RX0_0N: J1.16, J3.5
/CAM_RX0_0P: J1.18, J3.7
/CAM_RX0_1N: J1.22, J3.13
/CAM_RX0_1P: J1.24, J3.15
/CAM_RX0_CLKN: J1.10, J3.9
/CAM_RX0_CLKP: J1.12, J3.11
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
Notes on the sheet:
코어 BTB (J1 짝, ST-BTB-058060-B / HCTL, 전면 보드 아랫면)
계약 5절 핀맵 · CSI 2레인 (CLK=RX2, D0=RX0, D1=RX3) 100R · I2C2 1.8V
VIN 4핀 (코어 5V) · CORE_1V8 300mA · CORE_3V3 1A (코어와 공유)
전면 2.8V LDO (RT9013-28, C-004 R9)
VIN 5V → FRONT_2V8 (DRV8837 VCC: VIH max 0.5×2.8 = 1.4V → 1.8V GPIO 여유 0.4V · LTR-329 VDD 2.4~3.6V)
ICR 구동 DRV8837 + CLA216-ICR
VM = VIN 5V · VCC = 2.8V (C-004 R9) · IN1 = IR_CUT (gpio495) · IN2 = WH_PWM (gpio352)
코일 20R 약 0.245A, 펄스 100~500ms (FW) · 기본 IN1 = IN2 = 0 (계약 C13)
센서 모듈 DF30 24P (BXF4677-GC2053) · 24MHz · 전원 스위치
모듈 3.3V 전원 3핀 ← CAM_EN 스위치 · CAM_1V8(Q6, 게이트 Q7/R17 → 자기 소스 풀업, N1) = MCLK(OE=VDD)·I2C 풀업 · RESET RC + BAT54 · C6 DNP 유지
MCLK 24MHz 발진기 (BTB에 MCLK 없음, 계약 9절) · 모듈↔J3 번호 대응은 추론 → 실물 도통
조도 LTR-329 · I2C2 상시 풀업
I2C2 1.8V · GC2053 0x3f · LTR-329 0x29 (VIO 1.7~3.6V) · 풀업 4.7k → CAM_1V8 스위칭 (O-33, V-004 R1) · LTR-329는 CAM_EN=1일 때만 폴링
LIGHT_SENSE 아날로그 차선 Q4/R11 DNP
IR LED 2스트링 · AL8860 x2 (A·B 실장, O-69)
12V_IR → Rs 0.1R → VSMA1085400 x2 직렬 → L 68uH → SW · 스트링당 1.0A (O-25, V-001 6)
IR_PWM High = 끔 · R12 풀업 → 기본 끔 (K1) · CTRL = IR_PWM 오픈드레인 공통 (분기 C2-5) · 기본 12V_IR 꺼짐 (eFuse SHDN) · 열: 스트링 평균 ≤1.6W = IR_PWM 듀티 ≤25% (O-31, FW 강제)
보드 간 JST GH 6P (직선 케이블 J7-n ↔ J4-(7−n), O-41)
계약 12A절 v1.8 · 3 ALS_INT_RSV · 4 SPARE1 (캐리어와 3·4 맞바꿈) · 12V_IR 2접점 x 1.0A
시험점 (계약 11절)
PWR_FLAG (ERC: 전원 입력 핀이 있는데 구동원이 없는 넷)
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
Board: 4 copper layers, 40.0 x 40.0 mm, 100 parts (76 on the bottom side), 45 nets.

Other parts of the board:
H1, H2, H3, H4: M1.6; MountingHole_M1.6_NPTH

Notices in the files:
README.md:
License: Apache-2.0
